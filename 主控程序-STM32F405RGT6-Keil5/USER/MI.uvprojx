# Keil uVision project MI.uvprojx, settings and files
target SCUDOGMOTOR (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SCUDOGMOTOR +hex
  c flags: Optim=1 uC99=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE;..\HARDWARE\IWDG;..\HARDWARE\MagneticValve;..\HARDWARE\VisionUSART;..\HARDWARE\DMA;..\HARDWARE\RemoteCtrl;..\HARDWARE\JY901;..\HARDWARE\UART2;..\HARDWARE\EncoderMotor;..\HARDWARE\SteeringGear
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/: system_init.c task.c led.c key.c timer.c
    ../HARDWARE/MagneticValve/: MagneticValve.c
    ../HARDWARE/VisionUSART/: VisionUSART.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/RemoteCtrl/: RemoteCtrl.c
    ../HARDWARE/JY901/: JY901.c
    ../HARDWARE/UART2/: UART2.c
    ../HARDWARE/EncoderMotor/: BrushMotor.c BrushPID.c Encoder&PWM.c
    ../HARDWARE/SteeringGear/: SteeringGear.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_exti.c stm32f4xx_dma.c stm32f4xx_iwdg.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group README
    ../: readme.txt
